# Keil uVision project SD_Test_3.uvprojx, settings and files
target SD_Test_3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SD_Test_3
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;                    ../Drivers/STM32F4xx_HAL_Driver/Inc;                    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                    ../Middlewares/Third_Party/FatFs/src/drivers;                    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                    ../Middlewares/Third_Party/FatFs/src;                    ../Drivers/CMSIS/Include;                    ..\Hardware;                    ..\Hardware\I2C;                    ..\Hardware\IMU;                    ..\Hardware\MPU9250;                    ..\Hardware\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/User
    ../Src/: stm32f4xx_it.c bsp_driver_sd.c fatfs.c stm32f4xx_hal_msp.c main.c
  group Hardware/
    ../Hardware/: MPU9255.h MPU9255.c
software components: CMSIS:CORE 4.1.0
